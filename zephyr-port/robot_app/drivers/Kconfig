## zephyr-port/zephyr_led_app/test/testcase.yaml
```yaml
tests:
  testing.ws2812:
    tags: ws2812 led
    platform_allow: native_posix
    integration_platforms:
      - native_posix
```
